Commit message: added a second obstacle

File: kautham_demos/models/obstacles/kitchen_stuff/cokecan/big_can.urdf (robot description, URDF)
Before this commit: robot can, 1 links, 0 joints
Links:
- link base: geometry collision cylinder length=1 radius=0.5; visual cylinder length=1 radius=0.5
