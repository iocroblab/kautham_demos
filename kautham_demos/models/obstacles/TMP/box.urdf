Commit message: modified files for the BT demo

File: kautham_demos/models/obstacles/TMP/box.urdf (robot description, URDF)
Before this commit: robot box8, 1 links, 0 joints
Links:
- link base: mass 1 -> None; geometry visual box size=0.1 0.1 0.07
